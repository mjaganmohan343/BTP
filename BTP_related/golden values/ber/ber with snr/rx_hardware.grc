options:
  parameters:
    author: pranav
    category: Custom
    description: 16-HexQAM simulation using native GRC blocks with custom constellation
    generate_options: qt_gui
    id: rx_hardware
    output_language: python
    title: 16-HQAM Hardware Receiver
  states: {}

blocks:
- name: Alpha
  id: variable
  parameters:
    value: '0.22'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '2850000000'
  states: {}
- name: cma_algo
  id: variable_adaptive_algorithm
  parameters:
    cons: hqam_const
    modulus: '1'
    step_size: eq_gain
    type: cma
  states: {}
- name: eq_gain
  id: variable
  parameters:
    comment: 0.005 or 0.0005 or 0.0001
    value: '0.0005'
  states: {}
- name: hqam_const
  id: variable_constellation
  parameters:
    comment: '16-HexQAM: 16 custom hexagonal IQ points, Es~1'
    const_points: '[-0.3333+1.1547j, 0.3333+1.1547j, -0.6667+0.5774j, 0.0000+0.5774j, 0.6667+0.5774j, 1.3333+0.5774j, -0.3333+1e-10j, 0.3333+1e-10j, 1.0000+1e-10j, -0.6667-0.5774j, 0.0000-0.5774j, 0.6667-0.5774j, 1.3333-0.5774j, -0.3333-1.1547j, 0.3333-1.1547j, -1.0000+1e-09j]'
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '1'
    sym_map: '[7, 6, 5, 2, 0, 4, 3, 10, 8, 9, 11, 14, 12, 13, 15, 1]'
    type: calcdist
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), Alpha, 11*sps*nfilts)
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '38'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: timing_loop_bw
  id: variable
  parameters:
    comment: 0.01 to 0.03
    value: '0.03'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Capture unpacked bits for offline BER calculation
    file: rx_bits.bin
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    comment: Discard uncorrected receiver bit decisions
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '4'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Decode phase-corrected complex symbols into indices
    constellation: hqam_const
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: hqam_const
    fmax: '0.05'
    fmin: '-0.05'
    loop_bw: '0.06'
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '10'
    sps: '1'
    symbols: '[1.0, 1.0, 1.0, -1.0, -1.0, -1.0, 1.0, -1.0, -1.0, 1.0, -1.0]'
    threshold: '0.9'
    threshold_method: digital.THRESHOLD_DYNAMIC
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '45'
    rolloff: Alpha
    samps_per_sym: sps
    type: cc
    w: '0.02'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: cma_algo
    num_taps: '15'
    sps: '1'
    training_sequence: '[]'
    training_start_tag: '""'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """Asymmetry-Based Automatic Blind Phase Resolver & SNR Estimator"""
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Phase Ambiguity Resolver',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.flip_state = 1.0
              self.score = 0
              
              # 16-HQAM constellation points for slicing and SNR estimation
              self.constellation = np.array([
                  -0.3333+1.1547j,  0.3333+1.1547j, -0.6667+0.5774j,  0.0000+0.5774j,
                   0.6667+0.5774j,  1.3333+0.5774j, -0.3333+0j,       0.3333+0j,
                   1.0000+0j,      -0.6667-0.5774j,  0.0000-0.5774j,  0.6667-0.5774j,
                   1.3333-0.5774j, -0.3333-1.1547j,  0.3333-1.1547j, -1.0000+0j
              ], dtype=np.complex64)
              
              self.avg_signal_power = 1.0
              self.avg_noise_power = 0.05
              self.snr_db = 13.0

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              
              if len(in0) == 0:
                  return 0
                  
              # Count extreme symbols on real axis (+1.33 vs -1.33)
              k = max(2, int(len(in0) * 0.04))
              sorted_real = np.sort(in0.real)
              top_mag = np.mean(sorted_real[-k:])
              bot_mag = np.abs(np.mean(sorted_real[:k]))
              
              if top_mag > bot_mag * 1.06:
                  self.flip_state = 1.0
              elif bot_mag > top_mag * 1.06:
                  self.flip_state = -1.0
                  
              corrected = in0 * self.flip_state
              out[:] = corrected
              
              # Vectorized constellation slicing for SNR estimation
              dists = np.abs(corrected[:, np.newaxis] - self.constellation[np.newaxis, :])
              closest_idx = np.argmin(dists, axis=1)
              closest_pts = self.constellation[closest_idx]
              
              noise_vect = corrected - closest_pts
              noise_p = np.mean(np.abs(noise_vect)**2)
              signal_p = np.mean(np.abs(closest_pts)**2)
              
              alpha_ema = 0.05
              self.avg_signal_power = (1.0 - alpha_ema) * self.avg_signal_power + alpha_ema * signal_p
              self.avg_noise_power = (1.0 - alpha_ema) * self.avg_noise_power + alpha_ema * noise_p
              
              if self.avg_noise_power > 0:
                  self.snr_db = 10 * np.log10(self.avg_signal_power / self.avg_noise_power)
              else:
                  self.snr_db = 0.0
                  
              return len(out)
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import time
      import os
      import inspect

      class blk(gr.sync_block):
          """Phase Ambiguity Resolver"""
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='BER Calculator & CSV Logger',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.preamble = np.array([8, 8, 8, 15, 15, 15, 8, 15, 15, 8, 15], dtype=np.uint8)
              np.random.seed(42)
              self.payload_ref = np.random.randint(0, 16, size=989, dtype=np.uint8)
              
              # Precompute 16x16 Hamming distance LUT
              self.LUT = np.zeros((16, 16), dtype=np.uint8)
              for i in range(16):
                  for j in range(16):
                      self.LUT[i, j] = bin(i ^ j).count('1')
                      
              self.buffer = np.array([], dtype=np.uint8)
              self.total_bits = 0
              self.total_errors = 0
              self.frame_count = 0
              self.printed_debug = False
              
              # Absolute path for CSV file so it writes next to the script
              dir_path = os.path.dirname(os.path.abspath(__file__)) if '__file__' in locals() else '.'
              self.csv_path = os.path.join(dir_path, 'ber_log.csv')
              self.csv_file = open(self.csv_path, 'w')
              self.csv_file.write("timestamp,frame,total_bits,total_errors,ber,snr_db\n")
              self.csv_file.flush()

              # Self-contained GUI Label Injection via Stack Frames
              self.top_block = None
              self.ber_label = None
              self.gui_timer = None
              
              for frame_info in inspect.stack():
                  frame = frame_info.frame
                  if 'self' in frame.f_locals:
                      val = frame.f_locals['self']
                      if hasattr(val, 'top_grid_layout'):
                          self.top_block = val
                          break
                          
              if self.top_block:
                  try:
                      from PyQt5.QtWidgets import QLabel
                      from PyQt5.QtCore import QTimer
                      
                      self.ber_label = QLabel("Total Bits: 0 | Errors: 0 | BER: 0.00e+00 | SNR: 0.0 dB")
                      self.ber_label.setStyleSheet("font-size: 16px; font-weight: bold; color: blue; padding: 10px;")
                      self.top_block.top_grid_layout.addWidget(self.ber_label, 0, 0, 1, 2)
                      
                      self.gui_timer = QTimer()
                      self.gui_timer.setInterval(200)
                      self.gui_timer.timeout.connect(self.update_gui)
                      self.gui_timer.start()
                      print(f"[BER] Successfully injected GUI label and timer. CSV logging to: {self.csv_path}")
                  except Exception as e:
                      print(f"[BER] Failed to initialize GUI components: {e}")

          def update_gui(self):
              if self.ber_label and self.top_block:
                  bits = self.total_bits
                  errs = self.total_errors
                  ber = errs / bits if bits > 0 else 0
                  
                  # Retrieve SNR from epy_block_0
                  snr_db = 0.0
                  if hasattr(self.top_block, 'epy_block_0') and hasattr(self.top_block.epy_block_0, 'snr_db'):
                      snr_db = self.top_block.epy_block_0.snr_db
                      
                  self.ber_label.setText(f"Total Bits: {bits:,} | Errors: {errs:,} | BER: {ber:.2e} | SNR: {snr_db:.1f} dB")

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              
              if not self.printed_debug and len(in0) >= 100:
                  print("[BER DEBUG] First 100 decoded symbols:", in0[:100].tolist())
                  self.printed_debug = True
                  
              data = np.concatenate([self.buffer, in0])
              if len(data) >= 11:
                  mismatches = np.zeros(len(data) - 10, dtype=int)
                  for shift in range(11):
                      mismatches += (data[shift : len(data) - 10 + shift] != self.preamble[shift])
                      
                  match_indices = np.where(mismatches <= 1)[0]
                  
                  last_processed_idx = 0
                  for idx in match_indices:
                      if idx + 1000 <= len(data):
                          rx_pay = data[idx + 11 : idx + 1000]
                          errors = np.sum(self.LUT[rx_pay, self.payload_ref])
                          self.total_errors += errors
                          self.total_bits += 989 * 4
                          self.frame_count += 1
                          
                          # Retrieve SNR from epy_block_0
                          snr_db = 0.0
                          if self.top_block and hasattr(self.top_block, 'epy_block_0') and hasattr(self.top_block.epy_block_0, 'snr_db'):
                              snr_db = self.top_block.epy_block_0.snr_db
                              
                          if self.frame_count % 50 == 0:
                              ber = self.total_errors / self.total_bits if self.total_bits > 0 else 0
                              print(f"[BER] Frame: {self.frame_count} | Total Bits: {self.total_bits} | Errors: {self.total_errors} | BER: {ber:.2e} | SNR: {snr_db:.1f} dB")
                          self.csv_file.write(f"{time.time()},{self.frame_count},{self.total_bits},{self.total_errors},{self.total_errors/self.total_bits:.2e},{snr_db:.2f}\n")
                          self.csv_file.flush()
                          last_processed_idx = idx + 1000
                          
                  self.buffer = data[last_processed_idx:]
                  if len(self.buffer) > 1000:
                      self.buffer = self.buffer[-1000:]
              else:
                  self.buffer = data
                  
              out[:] = in0
              return len(out)

          def stop(self):
              if hasattr(self, 'gui_timer') and self.gui_timer:
                  self.gui_timer.stop()
              if hasattr(self, 'csv_file') and self.csv_file:
                  self.csv_file.close()
              return True
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: 1,0,1,1
    gui_hint: 1,0,1,1
    label1: Post-Equalizer
    label2: Post-Sync
    name: '"16-HexQAM Received Constellation"'
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: dark blue
    comment: 2,0,1,2
    ctrlpanel: 'True'
    gui_hint: 2,0,1,2
    label1: RX Decoded Bits
    name: '"Decoded Bits"'
    size: '128'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: Alpha
    decim: '1'
    gain: '1.0'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: '1000000'
    center_freq0: center_freq
    comment: far user
    gain0: rx_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', blocks_file_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', epy_block_1, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_null_sink_1, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0, '1']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0, '2']
- [digital_constellation_receiver_cb_0, '4', epy_block_0, '0']
- [digital_corr_est_cc_0, '0', digital_constellation_receiver_cb_0, '0']
- [digital_corr_est_cc_0, '0', qtgui_const_sink_x_0, '1']
- [digital_fll_band_edge_cc_0, '0', root_raised_cosine_filter_0, '0']
- [digital_linear_equalizer_0, '0', digital_corr_est_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [epy_block_0, '0', digital_constellation_decoder_cb_0, '0']
- [epy_block_0, '0', qtgui_const_sink_x_0, '0']
- [epy_block_1, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [uhd_usrp_source_0, '0', analog_agc_xx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
