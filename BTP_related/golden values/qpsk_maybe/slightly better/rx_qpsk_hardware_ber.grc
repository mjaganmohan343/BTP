options:
  parameters:
    author: pranav
    category: Custom
    description: QPSK Hardware Receiver
    generate_options: qt_gui
    id: rx_qpsk_hardware_ber
    output_language: python
    title: QPSK Hardware Receiver
  states: {}

blocks:
- name: Alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '2850000000'
  states: {}
- name: cma_algo
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk_const
    modulus: '1'
    step_size: eq_gain
    type: cma
  states: {}
- name: costas_loop_bw
  id: variable_qtgui_range
  parameters:
    label: Costas Loop BW
    start: '0.001'
    step: '0.001'
    stop: '0.2'
    value: '0.0628'
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    label: CMA EQ Gain
    start: '0.0001'
    step: '0.0001'
    stop: '0.01'
    value: '0.0005'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: qpsk_const
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), Alpha, 11*sps*nfilts)
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '1'
    stop: '76'
    value: '55'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    label: Timing Loop BW
    start: '0.001'
    step: '0.001'
    stop: '0.1'
    value: '0.03'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk_const
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: costas_loop_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '45'
    rolloff: Alpha
    samps_per_sym: sps
    type: cc
    w: '0.02'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: cma_algo
    num_taps: '15'
    sps: '1'
    training_sequence: '[]'
    training_start_tag: '""'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: '1.0'
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import time
      import os
      import inspect

      class blk(gr.sync_block):
          """Robust QPSK BER Calculator & CSV Logger (Frame Jump Parser)"""
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='BER Calculator & CSV Logger',
                  in_sig=[np.uint8],
                  out_sig=[]
              )
              self.preamble = np.array([3, 3, 3, 3, 3, 0, 0, 3, 3, 0, 3, 0, 3, 3, 3, 3, 3, 3, 0, 0, 3, 3, 0, 3, 0, 3, 3, 0, 0, 3, 0, 3], dtype=np.uint8)
              np.random.seed(42)
              self.payload_ref = np.random.randint(0, 4, size=968, dtype=np.uint8)
              
              # Precompute 4x4 Hamming distance LUT for QPSK (2 bits)
              self.LUT = np.zeros((4, 4), dtype=np.uint8)
              for i in range(4):
                  for j in range(4):
                      self.LUT[i, j] = bin(i ^ j).count('1')
                      
              self.buffer = np.array([], dtype=np.uint8)
              self.total_bits = 0
              self.total_errors = 0
              self.frame_count = 0
              self.printed_debug = False
              
              dir_path = os.path.dirname(os.path.abspath(__file__)) if '__file__' in locals() else '.'
              self.csv_path = os.path.join(dir_path, 'ber_log_qpsk.csv')
              self.csv_file = open(self.csv_path, 'w')
              self.csv_file.write("timestamp,frame,total_bits,total_errors,ber,snr_db\n")
              self.csv_file.flush()

              # GUI Label Injection
              self.top_block = None
              self.ber_label = None
              self.gui_timer = None
              
              for frame_info in inspect.stack():
                  frame = frame_info.frame
                  if 'self' in frame.f_locals:
                      val = frame.f_locals['self']
                      if hasattr(val, 'top_grid_layout'):
                          self.top_block = val
                          break
                          
              if self.top_block:
                  try:
                      from PyQt5.QtWidgets import QLabel
                      from PyQt5.QtCore import QTimer
                      
                      self.ber_label = QLabel("Total Bits: 0 | Errors: 0 | BER: 0.00e+00 | SNR: 0.0 dB")
                      self.ber_label.setStyleSheet("font-size: 16px; font-weight: bold; color: blue; padding: 10px;")
                      self.top_block.top_grid_layout.addWidget(self.ber_label, 0, 0, 1, 2)
                      
                      self.gui_timer = QTimer()
                      self.gui_timer.setInterval(200)
                      self.gui_timer.timeout.connect(self.update_gui)
                      self.gui_timer.start()
                      print(f"[BER] Successfully injected GUI label and timer. CSV logging to: {self.csv_path}")
                  except Exception as e:
                      print(f"[BER] Failed to initialize GUI components: {e}")

          def update_gui(self):
              if self.ber_label and self.top_block:
                  bits = self.total_bits
                  errs = self.total_errors
                  ber = errs / bits if bits > 0 else 0
                  
                  self.ber_label.setText(f"Total Bits: {bits:,} | Errors: {errs:,} | BER: {ber:.2e}")

          def work(self, input_items, output_items):
              in0 = input_items[0]
              
              data = np.concatenate([self.buffer, in0])
              
              idx = 0
              while idx + 1000 <= len(data):
                  window = data[idx : idx + 32]
                  mismatches = int(np.sum(window != self.preamble))
                  
                  if mismatches <= 2:
                      rx_pay = data[idx + 32 : idx + 1000]
                      errors = int(np.sum(self.LUT[rx_pay, self.payload_ref]))
                      self.total_errors += errors
                      self.total_bits += 968 * 2
                      self.frame_count += 1
                      
                      if self.frame_count % 50 == 0:
                          ber = self.total_errors / self.total_bits if self.total_bits > 0 else 0
                          print(f"[BER] Frame: {self.frame_count} | Total Bits: {self.total_bits:,} | Errors: {self.total_errors:,} | BER: {ber:.2e}")
                      
                      self.csv_file.write(f"{time.time()},{self.frame_count},{self.total_bits},{self.total_errors},{self.total_errors/self.total_bits:.2e}\n")
                      self.csv_file.flush()
                      
                      idx += 1000
                  else:
                      idx += 1
                      
              self.buffer = data[idx:]
              return len(in0)

          def stop(self):
              if hasattr(self, 'gui_timer') and self.gui_timer:
                  self.gui_timer.stop()
              if hasattr(self, 'csv_file') and self.csv_file:
                  self.csv_file.close()
              return True
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: center_freq
    gain0: rx_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', epy_block_1, '0']
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [uhd_usrp_source_0, '0', digital_fll_band_edge_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
