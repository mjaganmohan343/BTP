options:
  parameters:
    author: pranav
    category: Custom
    description: QPSK Hardware Receiver
    generate_options: qt_gui
    id: rx_qpsk_hardware_ber
    output_language: python
    title: QPSK Hardware Receiver
  states: {}

blocks:
- name: Alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '2850000000'
  states: {}
- name: costas_loop_bw
  id: variable_qtgui_range
  parameters:
    label: Costas Loop BW
    start: '0.001'
    step: '0.001'
    stop: '0.2'
    value: '0.02'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: qpsk_const
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), Alpha, 11*sps*nfilts)
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '1'
    stop: '76'
    value: '36'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    label: Timing Loop BW
    start: '0.001'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk_const
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: costas_loop_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '128'
    rolloff: Alpha
    samps_per_sym: sps
    type: cc
    w: '0.01'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: '1.0'
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import inspect

      class blk(gr.sync_block):
          """FFT Out-of-Band SNR Estimator (Es/N0)"""
          def __init__(self, sps=4, samp_rate=1000000):
              gr.sync_block.__init__(
                  self,
                  name='FFT Out-of-Band SNR Estimator',
                  in_sig=[np.complex64],
                  out_sig=[]
              )
              self.sps = sps
              self.samp_rate = samp_rate
              self.N_fft = 2048
              self.win = np.blackman(self.N_fft)
              self.win_scale = np.sum(self.win**2)
              
              freqs = np.fft.fftshift(np.fft.fftfreq(self.N_fft, d=1.0/self.samp_rate))
              # Out-of-band bins: +300 kHz to +480 kHz and -480 kHz to -300 kHz
              self.oob_mask = (np.abs(freqs) > 300e3) & (np.abs(freqs) < 480e3)
              self.current_snr = 0.0
              self.buf = np.array([], dtype=np.complex64)
              
              self.top_block = None
              for frame_info in inspect.stack():
                  frame = frame_info.frame
                  if 'self' in frame.f_locals:
                      val = frame.f_locals['self']
                      if hasattr(val, 'top_grid_layout'):
                          self.top_block = val
                          break

          def work(self, input_items, output_items):
              in0 = input_items[0]
              if len(in0) == 0:
                  return 0
                  
              self.buf = np.concatenate([self.buf, in0])
              while len(self.buf) >= self.N_fft:
                  chunk = self.buf[:self.N_fft]
                  self.buf = self.buf[self.N_fft:]
                  
                  spec = np.fft.fftshift(np.fft.fft(chunk * self.win))
                  psd = (np.abs(spec)**2) / (self.N_fft * self.win_scale)
                  
                  # Noise spectral density per bin in out-of-band region
                  N0_bin_est = np.mean(psd[self.oob_mask])
                  P_noise_total = N0_bin_est * self.N_fft
                  P_total = np.mean(np.abs(chunk)**2)
                  P_sig = max(P_total - P_noise_total, 1e-12)
                  
                  if P_noise_total > 1e-12:
                      snr_lin = self.sps * (P_sig / P_noise_total)
                      snr_inst = 10.0 * np.log10(snr_lin)
                      # Exponential smoothing
                      self.current_snr = snr_inst if self.current_snr == 0.0 else 0.95 * self.current_snr + 0.05 * snr_inst
                      if self.top_block:
                          self.top_block.fft_snr = self.current_snr
                          
              # Prevent buffer unbounded growth
              if len(self.buf) > 16384:
                  self.buf = self.buf[-self.N_fft:]
                  
              return len(in0)
    comment: FFT Out-of-Band Noise Estimator (Es/N0)
    samp_rate: samp_rate
    sps: sps
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import time
      import os
      import inspect

      class blk(gr.sync_block):
          """Robust QPSK BER & SNR Calculator & CSV Logger"""
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='BER & SNR Calculator',
                  in_sig=[np.uint8, np.complex64],  # Port 0: Decoded Bytes, Port 1: Costas Symbols
                  out_sig=[]
              )
              self.preamble = np.array([3, 3, 3, 3, 3, 0, 0, 3, 3, 0, 3, 0, 3, 3, 3, 3, 3, 3, 0, 0, 3, 3, 0, 3, 0, 3, 3, 0, 0, 3, 0, 3], dtype=np.uint8)
              np.random.seed(42)
              self.payload_ref = np.random.randint(0, 4, size=968, dtype=np.uint8)
              
              # Precompute 4x4 Hamming distance LUT for QPSK (2 bits)
              self.LUT = np.zeros((4, 4), dtype=np.uint8)
              for i in range(4):
                  for j in range(4):
                      self.LUT[i, j] = bin(i ^ j).count('1')
                      
              self.buffer = np.array([], dtype=np.uint8)
              self.total_bits = 0
              self.total_errors = 0
              self.frame_count = 0
              self.current_snr = 0.0
              self.evm_snr = 0.0
              
              dir_path = os.path.dirname(os.path.abspath(__file__)) if '__file__' in locals() else '.'
              self.csv_path = os.path.join(dir_path, 'ber_log_qpsk.csv')
              self.csv_file = open(self.csv_path, 'w')
              self.csv_file.write("timestamp,frame,total_bits,total_errors,ber,snr_db\n")
              self.csv_file.flush()

              # GUI Label Injection
              self.top_block = None
              self.ber_label = None
              self.gui_timer = None
              
              for frame_info in inspect.stack():
                  frame = frame_info.frame
                  if 'self' in frame.f_locals:
                      val = frame.f_locals['self']
                      if hasattr(val, 'top_grid_layout'):
                          self.top_block = val
                          break
                          
              if self.top_block:
                  try:
                      from PyQt5.QtWidgets import QLabel
                      from PyQt5.QtCore import QTimer
                      
                      self.ber_label = QLabel("Total Bits: 0 | Errors: 0 | BER: 0.00e+00 | SNR: 0.0 dB")
                      self.ber_label.setStyleSheet("font-size: 16px; font-weight: bold; color: blue; padding: 10px;")
                      self.top_block.top_grid_layout.addWidget(self.ber_label, 0, 0, 1, 2)
                      
                      self.gui_timer = QTimer()
                      self.gui_timer.setInterval(200)
                      self.gui_timer.timeout.connect(self.update_gui)
                      self.gui_timer.start()
                      print(f"[BER/SNR] Successfully initialized. Logging to: {self.csv_path}")
                  except Exception as e:
                      print(f"[BER/SNR] GUI Init Warning: {e}")

          def update_gui(self):
              if self.ber_label and self.top_block:
                  bits = self.total_bits
                  errs = self.total_errors
                  ber = errs / bits if bits > 0 else 0
                  self.ber_label.setText(f"Total Bits: {bits:,} | Errors: {errs:,} | BER: {ber:.2e} | SNR: {self.current_snr:.1f} dB (EVM: {self.evm_snr:.1f} dB)")

          def work(self, input_items, output_items):
              in_bytes = input_items[0]
              in_syms = input_items[1]
              
              # 1. Decision-Directed EVM calculation on Costas Loop Symbols
              if len(in_syms) > 100:
                  I = np.real(in_syms)
                  Q = np.imag(in_syms)
                  A = np.mean(np.abs(I) + np.abs(Q)) / 2.0
                  if A > 1e-4:
                      I_hat = A * np.sign(I)
                      Q_hat = A * np.sign(Q)
                      noise_pwr = np.mean((I - I_hat)**2 + (Q - Q_hat)**2)
                      sig_pwr = 2.0 * (A**2)
                      if noise_pwr > 1e-9:
                          snr_lin = sig_pwr / noise_pwr
                          snr_inst = 10.0 * np.log10(snr_lin)
                          self.evm_snr = snr_inst if self.evm_snr == 0.0 else 0.95 * self.evm_snr + 0.05 * snr_inst
                          self.current_snr = self.evm_snr

              # 2. Check for FFT Out-of-Band SNR from top_block
              if self.top_block and hasattr(self.top_block, 'fft_snr'):
                  self.current_snr = self.top_block.fft_snr

              # 3. Frame Parsing & BER Computation
              data = np.concatenate([self.buffer, in_bytes])
              idx = 0
              while idx + 1000 <= len(data):
                  window = data[idx : idx + 32]
                  mismatches = int(np.sum(window != self.preamble))
                  
                  if mismatches <= 2:
                      rx_pay = data[idx + 32 : idx + 1000]
                      errors = int(np.sum(self.LUT[rx_pay, self.payload_ref]))
                      self.total_errors += errors
                      self.total_bits += 968 * 2
                      self.frame_count += 1
                      
                      ber = self.total_errors / self.total_bits if self.total_bits > 0 else 0
                      if self.frame_count % 50 == 0:
                          print(f"[BER] Frame: {self.frame_count} | Bits: {self.total_bits:,} | Errors: {self.total_errors:,} | BER: {ber:.2e} | SNR: {self.current_snr:.1f} dB (EVM: {self.evm_snr:.1f} dB)")
                      
                      self.csv_file.write(f"{time.time()},{self.frame_count},{self.total_bits},{self.total_errors},{ber:.2e},{self.current_snr:.2f}\n")
                      self.csv_file.flush()
                      
                      idx += 1000
                  else:
                      idx += 1
                      
              self.buffer = data[idx:]
              return len(in_bytes)

          def stop(self):
              if hasattr(self, 'gui_timer') and self.gui_timer:
                  self.gui_timer.stop()
              if hasattr(self, 'csv_file') and self.csv_file:
                  self.csv_file.close()
              return True
    comment: the SNR is in Es/No dB, not Eb/No be careful
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: uhd.tune_request(center_freq, samp_rate/2)
    gain0: rx_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_agc_xx_0, '0', epy_block_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', epy_block_1, '1']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_map_bb_0, '0', epy_block_1, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [uhd_usrp_source_0, '0', analog_agc_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
