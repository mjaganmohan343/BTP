options:
  parameters:
    author: pranav
    category: Custom
    description: QPSK Hardware BER Receiver using USRP B210
    generate_options: qt_gui
    id: rx_qpsk_hardware_ber
    output_language: python
    title: QPSK BER Hardware Receiver (Tunable)
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    comment: Carrier frequency (2.85 GHz)
    value: '2850000000'
  states: {}
- name: costas_loop_bw
  id: variable_qtgui_range
  parameters:
    comment: Phase and Fine Frequency Lock BW
    gui_hint: 1,3,1,1
    label: Costas Loop BW
    start: '0.001'
    step: '0.001'
    stop: '0.2'
    value: '0.0628'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: RRC excess bandwidth / roll-off factor
    value: '0.35'
  states: {}
- name: fine_freq
  id: variable_qtgui_range
  parameters:
    comment: Manual Fine Frequency Offset (Hz)
    gui_hint: 0,4,1,1
    label: Fine Frequency
    start: '-15000'
    step: '10'
    stop: '15000'
    value: '0'
  states: {}
- name: fll_loop_bw
  id: variable_qtgui_range
  parameters:
    comment: Coarse Frequency Offset Recovery BW
    gui_hint: 1,1,1,1
    label: FLL Band-Edge BW
    start: '0.001'
    step: '0.001'
    stop: '0.1'
    value: '0.02'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    comment: QPSK Gray Coded Constellation
    const_points: '[-0.707-0.707j, 0.707-0.707j, +0.707+0.707j, -0.707+0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    comment: Hardware RX Gain slider
    gui_hint: 1,0,1,1
    label: RX Gain (dB)
    start: '0'
    step: '1'
    stop: '76'
    value: '48'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Baseband sample rate (1.0 MSps)
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples per symbol
    value: '4'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    comment: Symbol Timing Recovery BW
    gui_hint: 1,2,1,1
    label: Symbol Sync Timing BW
    start: '0.001'
    step: '0.001'
    stop: '0.1'
    value: '0.03'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    comment: Power Normalization / Dynamic Range Scaling
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Digital Fine Frequency Shift
    freq: fine_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Capture unpacked bits for offline verification
    file: rx_qpsk_bits.bin
    type: byte
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: Unpacks 2 bits per QPSK symbol
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Slices complex symbols to QPSK indices (0,1,2,3)
    constellation: qpsk
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: 4th-Order Costas Loop for QPSK Phase & Fine Frequency Lock
    order: '4'
    w: costas_loop_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: Differential Decoder (Modulus 4) resolves 90-deg phase ambiguity
    modulus: '4'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    comment: Coarse Carrier Frequency Offset (CFO) Recovery
    filter_size: '45'
    rolloff: excess_bw
    samps_per_sym: sps
    type: cc
    w: fll_loop_bw
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: Inverse Gray Mapping
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: Symbol Timing Recovery (SPS -> 1 Sym/Samp)
    constellation: digital.constellation_qpsk().base()
    damping: '1.0'
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import time
      import os
      import inspect

      class blk(gr.sync_block):
          """QPSK BER & SNR Calculator & CSV Logger"""
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='QPSK BER & SNR Engine',
                  in_sig=[np.uint8, np.complex64],
                  out_sig=[np.uint8]
              )
              # 32-bit QPSK sync preamble
              self.preamble_bits = np.array([
                  1, 1, 1, 1, 1, 0, 0, 1,
                  1, 0, 1, 0, 1, 1, 1, 1,
                  1, 1, 0, 0, 1, 1, 0, 1,
                  0, 1, 1, 0, 0, 1, 0, 1
              ], dtype=np.uint8)
              np.random.seed(42)
              self.payload_ref = np.random.randint(0, 2, size=968, dtype=np.uint8)

              self.bit_buffer = np.array([], dtype=np.uint8)
              self.total_bits = 0
              self.total_errors = 0
              self.frame_count = 0

              # Real-time Decision-Directed SNR Estimation
              self.avg_signal_power = 1.0
              self.avg_noise_power = 0.01
              self.snr_db = 0.0

              # CSV Logging
              dir_path = os.path.dirname(os.path.abspath(__file__)) if '__file__' in locals() else '.'
              self.csv_path = os.path.join(dir_path, 'ber_qpsk_log.csv')
              try:
                  self.csv_file = open(self.csv_path, 'w')
                  self.csv_file.write("timestamp,frame,total_bits,total_errors,ber,snr_db\n")
                  self.csv_file.flush()
              except Exception:
                  self.csv_file = None

              # Self-contained GUI Label Injection on Row 0
              self.top_block = None
              self.ber_label = None
              self.gui_timer = None

              for frame_info in inspect.stack():
                  frame = frame_info.frame
                  if 'self' in frame.f_locals:
                      val = frame.f_locals['self']
                      if hasattr(val, 'top_grid_layout'):
                          self.top_block = val
                          break

              if self.top_block:
                  try:
                      from PyQt5.QtWidgets import QLabel
                      from PyQt5.QtCore import QTimer

                      self.ber_label = QLabel("Total Bits: 0 | Errors: 0 | BER: 0.00e+00 | SNR: 0.0 dB")
                      self.ber_label.setStyleSheet("font-size: 16px; font-weight: bold; color: darkblue; padding: 8px; background-color: #f0f0f0; border: 1px solid #ccc;")
                      self.top_block.top_grid_layout.addWidget(self.ber_label, 0, 0, 1, 4)

                      self.gui_timer = QTimer()
                      self.gui_timer.setInterval(200)
                      self.gui_timer.timeout.connect(self.update_gui)
                      self.gui_timer.start()
                      print(f"[QPSK BER] Injected GUI Label on Row 0. CSV logging to: {self.csv_path}")
                  except Exception as e:
                      print(f"[QPSK BER] GUI initialization notice: {e}")

          def update_gui(self):
              if self.ber_label:
                  bits = self.total_bits
                  errs = self.total_errors
                  ber = errs / bits if bits > 0 else 0.0
                  snr = self.snr_db
                  color = "darkgreen" if (bits > 0 and ber < 1e-3) else "darkblue"
                  self.ber_label.setStyleSheet(f"font-size: 16px; font-weight: bold; color: {color}; padding: 8px; background-color: #f0f0f0; border: 1px solid #ccc;")
                  self.ber_label.setText(f"Total Bits: {bits:,} | Errors: {errs:,} | BER: {ber:.2e} | SNR: {snr:.1f} dB")

          def work(self, input_items, output_items):
              in_syms = input_items[0]
              in_iq = input_items[1]
              out_syms = output_items[0]

              n_samps = min(len(in_syms), len(in_iq))
              if n_samps == 0:
                  return 0

              # 1. Decision-Directed SNR from IQ samples
              iq_samps = in_iq[:n_samps]
              reals = np.sign(iq_samps.real)
              imags = np.sign(iq_samps.imag)
              reals[reals == 0] = 1.0
              imags[imags == 0] = 1.0
              sliced = (reals + 1j * imags) * 0.70710678

              noise = iq_samps - sliced
              noise_p = float(np.mean(np.abs(noise)**2))
              signal_p = float(np.mean(np.abs(sliced)**2))

              alpha_ema = 0.05
              self.avg_signal_power = (1.0 - alpha_ema) * self.avg_signal_power + alpha_ema * signal_p
              self.avg_noise_power = (1.0 - alpha_ema) * self.avg_noise_power + alpha_ema * noise_p

              if self.avg_noise_power > 1e-12:
                  raw_snr = 10.0 * np.log10(self.avg_signal_power / self.avg_noise_power)
                  self.snr_db = float(raw_snr)
              else:
                  self.snr_db = 40.0

              # 2. Fast Frame Sync & BER from symbols
              syms = in_syms[:n_samps]
              bits = np.zeros(n_samps * 2, dtype=np.uint8)
              bits[0::2] = (syms >> 1) & 1
              bits[1::2] = syms & 1

              buf = np.concatenate([self.bit_buffer, bits]) if len(self.bit_buffer) > 0 else bits
              buf_len = len(buf)

              idx = 0
              while idx + 1000 <= buf_len:
                  window_bits = buf[idx : idx + 32]
                  mismatches = int(np.sum(window_bits != self.preamble_bits))
                  if mismatches <= 2:
                      rx_payload = buf[idx + 32 : idx + 1000]
                      errors = int(np.sum(rx_payload ^ self.payload_ref))
                      self.total_errors += errors
                      self.total_bits += 968
                      self.frame_count += 1

                      if self.frame_count % 20 == 0:
                          ber = self.total_errors / self.total_bits if self.total_bits > 0 else 0.0
                          print(f"[QPSK BER] Frame: {self.frame_count} | Bits: {self.total_bits:,} | Errors: {self.total_errors} | BER: {ber:.2e} | SNR: {self.snr_db:.1f} dB")

                      if self.csv_file:
                          ber_curr = self.total_errors / self.total_bits if self.total_bits > 0 else 0.0
                          self.csv_file.write(f"{time.time():.3f},{self.frame_count},{self.total_bits},{self.total_errors},{ber_curr:.4e},{self.snr_db:.2f}\n")
                          self.csv_file.flush()

                      idx += 1000
                  else:
                      idx += 1

              self.bit_buffer = buf[idx:]
              if len(self.bit_buffer) > 4000:
                  self.bit_buffer = self.bit_buffer[-1000:]

              out_syms[:n_samps] = syms
              return n_samps

          def stop(self):
              if hasattr(self, 'gui_timer') and self.gui_timer:
                  self.gui_timer.stop()
              if hasattr(self, 'csv_file') and self.csv_file:
                  self.csv_file.close()
              return True
    comment: Real-Time QPSK Frame Sync, BER & SNR Calculator, GUI Stats & CSV Logging
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha2: '0.4'
    comment: Visualizes Locked Constellation (Blue) vs Pre-Costas Constellation (Red)
    grid: 'True'
    gui_hint: 2,0,1,2
    label1: '"Costas Phase Locked"'
    label2: '"Post Symbol-Sync (Rotating)"'
    name: '"QPSK Received Constellation"'
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    comment: Visualizes RF spectrum
    fc: center_freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 2,2,1,2
    label1: '"Received RF Spectrum"'
    name: '"RX Spectrum"'
    type: complex
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: Visualizes post-Costas I/Q components
    grid: 'True'
    gui_hint: 3,0,1,2
    label1: '"In-Phase (I)"'
    label2: '"Quadrature (Q)"'
    name: '"Demodulated I & Q Symbols"'
    size: '128'
    srate: samp_rate / sps
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: dark blue
    comment: Visualizes decoded bit stream
    grid: 'True'
    gui_hint: 3,2,1,2
    label1: '"Decoded QPSK Bits"'
    name: '"Decoded QPSK Bitstream"'
    size: '128'
    srate: (samp_rate / sps) * 2
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ylabel: Bit Value
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    comment: Matched Filter (RRC, Alpha=0.35, Taps=11*SPS)
    decim: '1'
    gain: '1.0'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: center_freq
    comment: USRP B210 Hardware Receiver Source
    gain0: rx_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', epy_block_1, '1']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_fll_band_edge_cc_0, '0', root_raised_cosine_filter_0, '0']
- [digital_map_bb_0, '0', epy_block_1, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '1']
- [epy_block_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [uhd_usrp_source_0, '0', analog_agc_xx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
