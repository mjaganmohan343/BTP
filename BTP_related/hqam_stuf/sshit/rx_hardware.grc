options:
  parameters:
    author: JaganMohan
    category: Custom
    description: 16-HexQAM simulation using native GRC blocks with custom constellation
    generate_options: qt_gui
    id: rx_hardware
    output_language: python
    title: 16-HQAM Hardware Receiver
  states: {}

blocks:
- name: Alpha
  id: variable
  parameters:
    value: '0.22'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '2850000000'
  states: {}
- name: cma_algo
  id: variable_adaptive_algorithm
  parameters:
    cons: hqam_const
    modulus: '1'
    step_size: eq_gain
    type: cma
  states: {}
- name: eq_gain
  id: variable
  parameters:
    comment: 0.005 or 0.0005 or 0.0001
    value: '0.0001'
  states: {}
- name: hqam_const
  id: variable_constellation
  parameters:
    comment: '16-HexQAM: 16 custom hexagonal IQ points, Es~1'
    const_points: '[-0.3333+1.1547j, 0.3333+1.1547j, -0.6667+0.5774j, 0.0000+0.5774j, 0.6667+0.5774j, 1.3333+0.5774j, -0.3333+1e-10j, 0.3333+1e-10j, 1.0000+1e-10j, -0.6667-0.5774j, 0.0000-0.5774j, 0.6667-0.5774j, 1.3333-0.5774j, -0.3333-1.1547j, 0.3333-1.1547j, -1.0000+1e-09j]'
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '1'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15]'
    type: calcdist
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), Alpha, 11*sps*nfilts)
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: timing_loop_bw
  id: variable
  parameters:
    value: '0.03'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '4'
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: hqam_const
    fmax: '0.05'
    fmin: '-0.05'
    loop_bw: '0.06'
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '10'
    sps: '1'
    symbols: '[1.0, 1.0, 1.0, -1.0, -1.0, -1.0, 1.0, -1.0, -1.0, 1.0, -1.0]'
    threshold: '0.5'
    threshold_method: digital.THRESHOLD_DYNAMIC
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '45'
    rolloff: Alpha
    samps_per_sym: sps
    type: cc
    w: '0.02'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: cma_algo
    num_taps: '15'
    sps: '1'
    training_sequence: '[]'
    training_start_tag: '""'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """Phase Ambiguity Resolver"""
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Phase Ambiguity Resolver',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.phase_correction = 1.0

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              
              tags = self.get_tags_in_window(0, 0, len(in0))
              tag_offsets = [t.offset - self.nitems_read(0) for t in tags]
              tag_dict = {tag_offsets[i]: tags[i] for i in range(len(tags))}
              
              for i in range(len(in0)):
                  if i in tag_dict:
                      tag = tag_dict[i]
                      if pmt.to_python(tag.key) == "phase_est":
                          phase_val = pmt.to_double(tag.value)
                          if np.cos(phase_val) < 0:
                              self.phase_correction = -1.0
                          else:
                              self.phase_correction = 1.0
                  out[i] = in0[i] * self.phase_correction
                  
              return len(out)
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: 1,0,1,1
    gui_hint: 1,0,1,1
    label1: Post-Equalizer
    label2: Post-Sync
    name: '"16-HexQAM Received Constellation"'
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: dark blue
    comment: 2,0,1,2
    ctrlpanel: 'True'
    gui_hint: 2,0,1,2
    label1: RX Decoded Bits
    name: '"Decoded Bits"'
    size: '128'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: Alpha
    decim: '1'
    gain: '1.0'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: '1000000'
    center_freq0: center_freq
    comment: far user
    gain0: rx_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', blocks_char_to_float_0_0, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0, '1']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0, '2']
- [digital_constellation_receiver_cb_0, '4', qtgui_const_sink_x_0, '0']
- [digital_corr_est_cc_0, '0', epy_block_0, '0']
- [digital_fll_band_edge_cc_0, '0', root_raised_cosine_filter_0, '0']
- [digital_linear_equalizer_0, '0', digital_corr_est_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [epy_block_0, '0', digital_constellation_receiver_cb_0, '0']
- [epy_block_0, '0', qtgui_const_sink_x_0, '1']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [uhd_usrp_source_0, '0', analog_agc_xx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
